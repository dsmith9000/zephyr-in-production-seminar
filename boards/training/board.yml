## boards/training/board.yml
```yaml
board:
  name: training
  full_name: My Training Board
  vendor: nxp
  socs:
  - name: mcxa156
```
